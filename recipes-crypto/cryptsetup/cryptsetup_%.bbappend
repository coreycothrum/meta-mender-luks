RDEPENDS:${PN}                 += "lvm2"
RRECOMMENDS:${PN}:class-target += "lvm2-udevrules"
