RRECOMMENDS:${PN} += " \
  kernel-module-tpm-crb \
  kernel-module-tpm-tis \
"
