require mender-luks-encrypt-image.inc
inherit nativesdk
